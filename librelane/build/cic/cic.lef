VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO cic
  CLASS BLOCK ;
  FOREIGN cic 0 0 ;
  ORIGIN 0.000 0.000 ;
  SIZE 148.960 BY 108.680 ;
  SYMMETRY X Y ;

  OBS
    LAYER Metal5 ;
      RECT 0.000 0.000 148.960 108.680 ;
  END
END cic

END LIBRARY
